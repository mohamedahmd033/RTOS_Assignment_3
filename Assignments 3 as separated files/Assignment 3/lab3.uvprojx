# Keil uVision project lab3.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lab3
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Files
    ./: main.c ADC.c Delay_Functions_GPTimer0.c LCD.c toStringConverter.c GP_Timer1.c
  group Header Files
    ./: tm4c123gh6pm.h hw_memmap.h hw_sysctl.h hw_types.h ADC.h Delay_Functions_GPTimer0.h LCD.h registers_operations_macros.h std_types.h toStringConverter.h FreeRTOSConfig.h GP_Timer1.h
software components: RTOS:Config 10.4.3, RTOS:Core 10.4.3, RTOS:Heap 10.4.3, CMSIS:CORE 5.5.0, Device:Startup 1.0.1
